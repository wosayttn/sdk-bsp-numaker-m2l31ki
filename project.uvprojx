# Keil uVision project project.uvprojx, settings and files
target rtthread-m2l31 (6100001::V6.10.1::.\ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\m2l31\StdDriver;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\include;libraries\m2l31\StdDriver\inc;.;board;libraries\m2l31\CMSIS\Core\Include;rt-thread\components\libc\posix\io\poll;applications;rt-thread\components\libc\compilers\common\include;libraries\m2l31\StdDriver\src;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\nu_packages\NuUtils\inc;rt-thread\libcpu\arm\cortex-m23;rt-thread\components\drivers\include;board\NuPinConfig;libraries\m2l31\rtt_port;rt-thread\components\finsh;rt-thread\libcpu\arm\common;rt-thread\components\fal\inc;board\NuClockConfig;rt-thread\components\utilities\utest;rt-thread\components\libc\compilers\common\extension;libraries\m2l31\Device\Nuvoton\M2L31\Include;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  scatter file: .\linking_scripts\m2l31_flash.sct
  group Applications
    applications/: main.c mnt.c pm_test.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: custom_loader.c board_dev.c nutool_modclkcfg.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/rtc/: alarm.c rtc.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/m2l31/Device/Nuvoton/M2L31/Source/: startup_M2L31.c system_M2L31.c
    libraries/m2l31/rtt_port/: drv_canfd.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_gpio.c drv_i2c.c drv_lpadc.c drv_lpi2c.c drv_lpspi.c drv_lpsram.c drv_lptimer.c drv_lpuart.c drv_otg.c drv_pdma.c drv_pwm.c drv_qspi.c drv_rmc.c drv_rtc.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_ttmr.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/m2l31/StdDriver/src/: nu_acmp.c nu_canfd.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_eqei.c nu_gpio.c nu_i2c.c nu_lpadc.c nu_lpgpio.c nu_lpi2c.c nu_lppdma.c nu_lpspi.c nu_lptmr.c nu_lptmr_pwm.c nu_lpuart.c nu_pdma.c nu_pwm.c nu_qspi.c nu_rmc.c nu_rng.c nu_rtc.c nu_spi.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_tk.c nu_trng.c nu_ttmr.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
